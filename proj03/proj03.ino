const int sensorPin = A0;
const float baselineTemp = 23.0;

void setup() {
Serial.begin(9600);
for(int pinNumber=2; pinNumber<=5; pinNumber++) {
  pinMode(pinNumber, OUTPUT);
  digitalWrite(pinNumber, LOW);
  }
}

void loop() {
int sensorVal = analogRead(sensorPin);
Serial.print("Sensor Value: ");
Serial.print(sensorVal);

// convert the ADC reading value to voltage
float voltage = 5.0 * sensorVal/1024;
Serial.print(", Volts: ");
Serial.print(voltage);

// convert the voltage to temperatures in degrees
Serial.print(", Degrees C: ");
float temperature = (voltage - 0.5)*100;
Serial.println(temperature);

if (temperature < baselineTemp) {
  digitalWrite(2,LOW);
  digitalWrite(3,LOW);
  digitalWrite(4,LOW);
  } else if (temperature >= baselineTemp && temperature < baselineTemp+2) {
      digitalWrite(2,HIGH);
      digitalWrite(3,LOW);
      digitalWrite(4,LOW);
  } else if (temperature >= baselineTemp+2 && temperature < baselineTemp+4) {
          digitalWrite(2,HIGH);
          digitalWrite(3,HIGH);
          digitalWrite(4,LOW);
  } else if (temperature >= baselineTemp+4) {
              digitalWrite(2,HIGH);
              digitalWrite(3,HIGH);
              digitalWrite(4,HIGH);
  }
  delay(1);
}

